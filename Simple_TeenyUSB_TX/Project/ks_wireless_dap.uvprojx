# Keil uVision project ks_wireless_dap.uvprojx, settings and files
target ks_wireless_dap (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ks_wireless_dap +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=512
  c include: ..\usb_stack\inc;..\usb_stack\class;..\HAL_LIB\Inc;..\HAL_LIB\CMSIS\Include;..\HAL_LIB\stm32f103ret6;..\..\usb_stack\class;..\HAL_LIB\CMSIS\Device\ST\STM32F1xx\Include;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F0xx\Include;..\boards\stm32f072c8t6;..\CMSIS-DAP\Include;..\CMSIS-DAP\algo;..\USER;..\BSP;D:\Keil_v5\Arm\Packs\ARM\CMSIS\5.5.1\CMSIS\Include;D:\Keil_v5\Arm\Packs\ARM\CMSIS\5.5.1\CMSIS\Driver\Include;..\BSP\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c include.h online.c online.h wireless_rx.c wireless_rx.h wireless_tx.c wireless_tx.h offline.c offline.h button.c button.h show.c show.h
  group bsp
    ../BSP/: gpio.c gpio.h dma.c dma.h usart.c usart.h spi.c spi.h bsp_spi.c bsp_spi.h bsp_nrf2401.c bsp_nrf2401.h w25qxx.c w25qxx.h oled.c oled.h oledfont.h oledfont.c bsp_button.c bsp_button.h
  group CMSIS-DAP
    ../CMSIS-DAP/Source/: DAP.c DAP_vendor.c error.c JTAG_DP.c SW_DP.c SWD_flash.c SWD_host.c SWO.c SWD_opt.c
  group teeny_usb_stack
    ../usb_stack/src/: stm32_otg_init.c teeny_usb.c teeny_usb_stm32_fs_device.c teeny_usb_stm32_otg_device.c stm32_fs_init.c
  group teeny_usb_def
    ../USER/: teeny_usb_desc.c composite_device.c teeny_usb_init.h
  group usb_device
    ../usb_stack/class/: tusbd.c tusbd_cdc.c tusbd_hid.c tusbd_msc.c tusbd_user.c
  group stm32f103
    ../HAL_LIB/stm32f103ret6/: board.c startup_stm32f103xe.s system_stm32f10x.c
    ../BSP/: stm32f1xx_it.c
  group stm32f1_hal
    ../HAL_LIB/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group flash
    ../CMSIS-DAP/algo/: STM32F0xx_OPT.c STM32F10x_OPT.c STM32F3xx_OPT.c STM32F4xx_OTP.c STM32F7xx_OPT.c STM32H7xx.c STM32_ALGO.c
  group fatfs
    ../BSP/fatfs/: ff.c diskio.c
target stm32f103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f723_dap +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=2048
  c include: ..\..\usb_stack\inc;.;..\..\mcu_lib\st_driver\STM32F1xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F1xx\Include;..\boards\stm32f103ret6;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target stm32f3_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=2048
  c include: ..\..\usb_stack\inc;.;..\..\mcu_lib\st_driver\STM32F3xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\mcu_lib\st_driver\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f3_disco;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
target stm32f407_evk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE=8000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\mcu_lib\st_driver\STM32F4xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F4x\Include;..\boards\stm32f407_evk;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target stm32f723e_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\mcu_lib\st_driver\STM32F7xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\mcu_lib\st_driver\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f723e_disco;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 5.2.0
